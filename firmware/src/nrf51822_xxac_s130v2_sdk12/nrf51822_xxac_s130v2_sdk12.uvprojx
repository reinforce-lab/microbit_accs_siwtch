# Keil uVision project nrf51822_xxac_s130v2_sdk12.uvprojx, settings and files
target nrf51822_xxac (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF_DEBUG DEBUG USE_APP_CONFIG BLE_STACK_SUPPORT_REQD NRF51822  NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: ..\config;..\..\nRF5_SDK_12.3.0_d7731ad\components;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_advertising;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_dtm;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_racp;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ancs_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ans_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_bas;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_bas_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_cscs;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_cts_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_dfu;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_dis;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_gls;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hids;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hrs;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hrs_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hts;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ias;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ias_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_lbs;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_lbs_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_lls;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_nus;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_nus_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_rscs;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_rscs_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_tps;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\common;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\nrf_ble_qwr;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\peer_manager;..\..\nRF5_SDK_12.3.0_d7731ad\components\boards;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\adc;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\clock;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\common;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\comp;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\delay;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\gpiote;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\hal;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\i2s;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\lpcomp;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\pdm;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\power;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\ppi;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\pwm;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\qdec;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\rng;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\rtc;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\saadc;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\spi_master;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\spi_slave;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\swi;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\timer;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\twi_master;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\twis_slave;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\uart;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\usbd;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\wdt;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\bsp;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\button;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\crc16;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\crc32;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\csense;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\csense_drv;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\experimental_section_vars;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\fds;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\fstorage;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\gpiote;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\hardfault;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\hci;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\led_softblink;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\log;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\log\src;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\low_power_pwm;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\mem_manager;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\pwm;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\queue;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\scheduler;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\sensorsim;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\slip;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\timer;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\twi;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\uart;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\audio;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\cdc;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\cdc\acm;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid\generic;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid\kbd;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid\mouse;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\msc;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\config;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\util;..\..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\common\softdevice_handler;..\..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\s130\headers;..\..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\s130\headers\nrf51;..\..\nRF5_SDK_12.3.0_d7731ad\components\toolchain;..\..\nRF5_SDK_12.3.0_d7731ad\external\segger_rtt;../
  asm define: USE_APP_CONFIG BLE_STACK_SUPPORT_REQD NRF51822 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF51822,-DNRF_SD_BLE_API_VERSION=2,-DS130,-DNRF51,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\config;..\..\nRF5_SDK_12.3.0_d7731ad\components;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_advertising;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_dtm;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_racp;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ancs_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ans_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_bas;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_bas_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_cscs;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_cts_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_dfu;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_dis;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_gls;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hids;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hrs;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hrs_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hts;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ias;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ias_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_lbs;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_lbs_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_lls;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_nus;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_nus_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_rscs;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_rscs_c;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_tps;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\common;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\nrf_ble_qwr;..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\peer_manager;..\..\nRF5_SDK_12.3.0_d7731ad\components\boards;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\adc;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\clock;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\common;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\comp;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\delay;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\gpiote;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\hal;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\i2s;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\lpcomp;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\pdm;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\power;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\ppi;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\pwm;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\qdec;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\rng;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\rtc;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\saadc;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\spi_master;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\spi_slave;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\swi;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\timer;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\twi_master;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\twis_slave;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\uart;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\usbd;..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\wdt;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\bsp;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\button;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\crc16;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\crc32;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\csense;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\csense_drv;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\experimental_section_vars;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\fds;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\fstorage;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\gpiote;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\hardfault;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\hci;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\led_softblink;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\log;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\log\src;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\low_power_pwm;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\mem_manager;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\pwm;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\queue;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\scheduler;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\sensorsim;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\slip;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\timer;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\twi;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\uart;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\audio;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\cdc;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\cdc\acm;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid\generic;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid\kbd;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid\mouse;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\msc;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\config;..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\util;..\..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\common\softdevice_handler;..\..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\s130\headers;..\..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\s130\headers\nrf51;..\..\nRF5_SDK_12.3.0_d7731ad\components\toolchain;..\..\nRF5_SDK_12.3.0_d7731ad\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x6018
  group Application
    ../: advertising_manager.c app_gap.c battery_service.c ble_stack.c device_information_service.c main.c sensor_service.c twi_manager.c twi_slave_lis3dh.c app_manager.c value_type.c
  group nRF_BLE
    ../../nRF5_SDK_12.3.0_d7731ad/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/ble/ble_advertising/: ble_advertising.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/ble/ble_services/ble_bas/: ble_bas.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/ble/ble_services/ble_dis/: ble_dis.c
  group nRF_Drivers
    ../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/common/: nrf_drv_common.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/adc/: nrf_drv_adc.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/hal/: nrf_adc.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/twi_master/: nrf_drv_twi.c
  group nRF_Libraries
    ../../nRF5_SDK_12.3.0_d7731ad/components/libraries/scheduler/: app_scheduler.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/libraries/button/: app_button.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/libraries/crc16/: crc16.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/libraries/fds/: fds.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/libraries/fstorage/: fstorage.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/libraries/hardfault/: hardfault_implementation.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/libraries/sensorsim/: sensorsim.c
    ../../nRF5_SDK_12.3.0_d7731ad/components/libraries/timer/: app_timer_appsh.c app_timer.c
  group nRF_Log
    ../../nRF5_SDK_12.3.0_d7731ad/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../nRF5_SDK_12.3.0_d7731ad/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../nRF5_SDK_12.3.0_d7731ad/components/softdevice/common/softdevice_handler/: softdevice_handler_appsh.c softdevice_handler.c
target flash_s130_nrf51_2.0.1_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s130_nrf51_2.0.1_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\config
  asm misc: --cpreproc_opts=
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x6018
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1, Device:Startup 8.15.0
